options:
  parameters:
    author: Leonardo Baldin
    generate_options: qt_gui
    id: comnetsemu_srsran
    output_language: python
    title: srsRAN
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '23040000'
  states: {}
- name: zeromq_rep_sink_0
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2000
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_rep_sink_1
  id: zeromq_rep_sink
  parameters:
    address: tcp://*:2100
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_0
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2101
    timeout: '100'
    type: complex
  states: {}
- name: zeromq_req_source_1
  id: zeromq_req_source
  parameters:
    address: tcp://localhost:2001
    timeout: '100'
    type: complex
  states: {}

connections:
- [zeromq_req_source_0, '0', zeromq_rep_sink_0, '0']
- [zeromq_req_source_1, '0', zeromq_rep_sink_1, '0']

metadata:
  file_format: 1
